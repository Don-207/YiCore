# Keil uVision project ECG.uvprojx, settings and files
target ECG (6190000::V6.19::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: ECG +hex
  BeforeMake: python ..\..\..\scripts\yi_dts_gen.py --dts ..\app.dts --bindings ..\..\..\dts\bindings --output ..\generated
  BeforeMake: python ..\..\..\scripts\yi_build_info_gen.py --image application --version-file ..\VERSION --output ..\generated\yi_build_info.c
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../../../vendor/st/stm32cube/stm32f1xx_hal_driver/Inc/Legacy;../../../vendor/st/stm32cube/stm32f1xx_hal_driver/Inc;../../../vendor/st/cmsis/Device/ST/STM32F1xx/Include;../../../vendor/st/cmsis/Include;../../../core;../../../drivers/led;../generated;../../../drivers/uart;../../../drivers/gpio;../../../drivers/pinmux;../../../drivers/clock;../../../drivers/flash;../../../drivers/eeprom;../../../drivers/eeprom/at24c02;../../../drivers/timer;../../../drivers/spi;../../../drivers/i2c;../../../drivers/can;../../../drivers/adc;../../../drivers/adc/ads1298;../../../subsys/console;../../../subsys/log;../../../subsys/timer;../../../ports/rtt;../../../soc/st/stm32/stm32f1;../../../third_party/RTT;../../../third_party/lwrb/src/include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: ..\generated\yi_app.sct
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c stm32f1xx_it.c stm32f1xx_hal_msp.c
    ../App/: ecg_service.c ecg_protocol.c
  group Vendor/ST/STM32F1xx_HAL_Driver
    ../../../vendor/st/stm32cube/stm32f1xx_hal_driver/Src/: stm32f1xx_hal_spi.c stm32f1xx_hal_i2c.c stm32f1xx_hal_can.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Vendor/ST/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group YiCore/core
    ../../../core/: yi_device.c yi_build_info.c
  group YiCore/drivers
    ../../../drivers/led/: yi_led.c
    ../../../soc/st/stm32/stm32f1/: yi_uart_stm32.c yi_gpio_stm32f1.c yi_pinmux_stm32f1.c yi_clock_stm32f1.c yi_flash_stm32f1.c yi_timer_stm32f1.c yi_can_stm32f1.c yi_stm32_periph.c yi_stm32_system.c yi_i2c_stm32.c yi_spi_stm32.c yi_adc_stm32f1.c
    ../../../drivers/uart/: yi_uart_dma_lwrb.c
    ../../../drivers/flash/: yi_flash.c
    ../../../drivers/eeprom/: yi_eeprom.c
    ../../../drivers/eeprom/at24c02/: yi_at24c02.c
    ../../../drivers/spi/: yi_spi.c yi_soft_spi.c
    ../../../drivers/adc/: yi_adc.c
    ../../../drivers/adc/ads1298/: yi_ads1298.c
    ../../../drivers/i2c/: yi_i2c.c yi_soft_i2c.c
  group YiCore/generated
    ../generated/: yi_generated.c yi_build_info.c
  group YiCore/subsys
    ../../../subsys/console/: yi_console.c
    ../../../subsys/log/: yi_log.c
    ../../../subsys/timer/: yi_soft_timer.c
  group YiCore/ports
    ../../../ports/rtt/: yi_rtt.c
  group YiCore/third_party
    ../../../third_party/RTT/: SEGGER_RTT.c
    ../../../third_party/lwrb/src/lwrb/: lwrb.c
  group YiCore/docs
    ../../../docs/: architecture-roadmap.md
software components: CMSIS:CORE 5.6.0
